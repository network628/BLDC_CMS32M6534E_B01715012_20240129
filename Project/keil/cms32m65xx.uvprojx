# Keil uVision project cms32m65xx.uvprojx, settings and files
target CMS_MOTOR_CTRL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CMS32M6510GE24SS Cmsemicon
  pack: Cmsemicon.CMS32M6510.0.5.8
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: CMS_65_FOCB_V100 +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\CMSIS\Include;..\..\Device\Include;..\..\Driver\inc;..\code\head\0_user_h;..\code\head\1_motlib_h
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\Objects\CMS_65_FOCB_V100.sct
  group user_flie
    ../code/head/0_user_h/: para_define.h user_control.h
    ../code/source/0_user_s/: user_control.c
  group user_s
    ../code/source/0_user_s/: isr.c main.c interrupt.c hardinit.c softinit.c mc_ctrl.c mc_foc.c uart0.c
  group user_h
    ../code/head/0_user_h/: uart0.h
  group motlib_s
    ../code/source/1_motlib_s/: CMS_65_FOCB_V220.lib
  group driver_h
    ../../Driver/inc/: acmp.h adc.h adcldo.h ccp.h cgc.h common.h dac.h delay.h divsqrt.h epwm.h flash.h gpio.h i2c.h lsitimer.h pcbz.h pga.h ssp.h timer.h timer4.h uart.h wdt.h
  group driver_s
    ../../Driver/src/: acmp.c adc.c adcldo.c ccp.c cgc.c dac.c delay.c divsqrt.c epwm.c flash.c gpio.c i2c.c lsitimer.c pcbz.c pga.c ssp.c timer.c timer4.c uart.c wdt.c
  group doc
    ../code/source/: record.txt
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
